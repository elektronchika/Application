# Keil uVision project Project.uvprojx, settings and files
target Application (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Output +hex
  AfterMake: fromelf --m32 --output=Output\Output.srec Output\Output.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F411xE
  c misc: --C99
  c include: .\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x8007fff
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Source
    ./Source/: main.c main.h startup_stm32f411xe.s system_stm32f4xx.c system_stm32f4xx.h stm32f4xx.h stm32f411xe.h constants.h dio.c dio.h dio_cfg.c dio_cfg.h
software components: CMSIS:CORE 5.0.2
